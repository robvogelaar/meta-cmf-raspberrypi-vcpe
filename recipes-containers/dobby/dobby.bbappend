
CFLAGS_remove_qemux86broadband_kirkstone = " -mfloat-abi=hard -mcpu=cortex-a7 "
